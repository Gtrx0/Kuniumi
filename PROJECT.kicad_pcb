# Repository Gtrx0/Kuniumi

File README.md:

# PROJECT

# [Layout]()

## Features
*

## Warning
KiCad 5 or above is needed to open this project. KiCad 4 or below won't work.

## Credit
60% outline developed by Amtra5

## KiCad design PROJECT.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: C
C7, C8: C_Small
F1: Polyfuse_Small
J1: USB_mini_micro_B
R1, R2: 10k
SPI1: 2x3 SPI
SW1: SW_PUSH
U1: PRTR5V0U2X
U2: ATmega32U4
UR1, UR2: 22
UR5: 1M
USBCap1: 4.7uF
X1: XTAL_GND

Connections:
+5V: C1.1, C3.1, C4.1, C5.1, F1.2, R1.2, SPI1.2, U2.2, U2.7, U2.24, U2.34, U2.44
C0: SPI1.3, U2.9; also elsewhere on the board
C1: SPI1.4, U2.10; also elsewhere on the board
C2: SPI1.1, U2.11; also elsewhere on the board
C3: U2.12; also elsewhere on the board
C4: U2.19; also elsewhere on the board
C5: U2.18; also elsewhere on the board
C6: U2.20; also elsewhere on the board
C7: U2.21; also elsewhere on the board
C8: U2.25; also elsewhere on the board
C9: U2.26; also elsewhere on the board
C10: U2.27; also elsewhere on the board
C11: U2.28; also elsewhere on the board
C12: U2.29; also elsewhere on the board
C13: U2.30; also elsewhere on the board
D+: U2.4, UR2.2
D-: U2.3, UR1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.5 (GND), R2.1, SPI1.5, SW1.1, U1.1 (GND), U2.5, U2.15, U2.23, U2.35, U2.43, UR5.2, USBCap1.1, X1.3
unnamed: C2.1, U2.14
unnamed: C6.1, U2.6
unnamed: C7.1, U2.17, X1.1
unnamed: C8.1, U2.16, X1.2
unnamed: J1.2 (D-), U1.3 (IO2), UR1.1
unnamed: J1.3 (D+), U1.2 (IO1), UR2.1
unnamed: J1.6 (SHIELD), UR5.1, USBCap1.2
unnamed: R2.2, U2.33
R0: U2.31; also elsewhere on the board
R1: U2.32; also elsewhere on the board
R2: U2.36; also elsewhere on the board
R3: U2.37; also elsewhere on the board
R4: U2.41; also elsewhere on the board
RST: R1.1, SPI1.6, SW1.2, U2.13
VCC: F1.1, J1.1 (VUSB), U1.4 (VCC)

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62: D; D_SOD-123
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX44, MX45, MX46, MX47, MX48, MX49, MX50, MX51, MX52, MX53, MX54, MX56, MX59, MX63: MX-1U; ALPS_PLATE_SPRING
MX14: MX-2U; ALPS_PLATE_SPRING2U
MX15, MX58, MX60, MX62, MX64: MX-1.5U; ALPS_PLATE_SPRING1.5U
MX28: MX-ISO; ALPS_PLATE_SPRINGISOCOMBINED
MX29, MX43: MX-1.25U; ALPS_PLATE_SPRING_1.25U
MX30, MX55: MX-1.75U; ALPS_PLATE_SPRING_1.75U
MX57: MX-2.75U; ALPS_PLATE_SPRING2.75U
MX61: MX-7U; ALPS_PLATE_SPRING7U

Connections:
C0: MX1.1 (COL), MX15.1 (COL), MX29.1 (COL), MX30.1 (COL), MX43.1 (COL), MX58.1 (COL); also elsewhere on the board
C1: MX2.1 (COL), MX16.1 (COL), MX31.1 (COL), MX44.1 (COL), MX59.1 (COL); also elsewhere on the board
C2: MX3.1 (COL), MX17.1 (COL), MX32.1 (COL), MX45.1 (COL), MX60.1 (COL); also elsewhere on the board
C3: MX4.1 (COL), MX18.1 (COL), MX33.1 (COL), MX46.1 (COL); also elsewhere on the board
C4: MX5.1 (COL), MX19.1 (COL), MX34.1 (COL), MX47.1 (COL); also elsewhere on the board
C5: MX6.1 (COL), MX20.1 (COL), MX35.1 (COL), MX48.1 (COL); also elsewhere on the board
C6: MX7.1 (COL), MX21.1 (COL), MX36.1 (COL), MX49.1 (COL); also elsewhere on the board
C7: MX8.1 (COL), MX22.1 (COL), MX37.1 (COL), MX50.1 (COL), MX61.1 (COL); also elsewhere on the board
C8: MX9.1 (COL), MX23.1 (COL), MX38.1 (COL), MX51.1 (COL); also elsewhere on the board
C9: MX10.1 (COL), MX24.1 (COL), MX39.1 (COL), MX52.1 (COL); also elsewhere on the board
C10: MX11.1 (COL), MX25.1 (COL), MX40.1 (COL), MX53.1 (COL); also elsewhere on the board
C11: MX12.1 (COL), MX26.1 (COL), MX41.1 (COL), MX54.1 (COL), MX62.1 (COL); also elsewhere on the board
C12: MX13.1 (COL), MX27.1 (COL), MX42.1 (COL), MX55.1 (COL), MX63.1 (COL); also elsewhere on the board
C13: MX14.1 (COL), MX28.1 (COL), MX56.1 (COL), MX57.1 (COL), MX64.1 (COL); also elsewhere on the board
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed 50: D29.2 (A), MX29.2 (ROW), MX30.2 (ROW); also elsewhere on the board
unnamed: D30.2 (A), MX31.2 (ROW)
unnamed: D31.2 (A), MX32.2 (ROW)
unnamed: D32.2 (A), MX33.2 (ROW)
unnamed: D33.2 (A), MX34.2 (ROW)
unnamed: D34.2 (A), MX35.2 (ROW)
unnamed: D35.2 (A), MX36.2 (ROW)
unnamed: D36.2 (A), MX37.2 (ROW)
unnamed: D37.2 (A), MX38.2 (ROW)
unnamed: D38.2 (A), MX39.2 (ROW)
unnamed: D39.2 (A), MX40.2 (ROW)
unnamed: D40.2 (A), MX41.2 (ROW)
unnamed: D41.2 (A), MX42.2 (ROW)
unnamed: D42.2 (A), MX43.2 (ROW)
unnamed: D43.2 (A), MX44.2 (ROW)
unnamed: D44.2 (A), MX45.2 (ROW)
unnamed: D45.2 (A), MX46.2 (ROW)
unnamed: D46.2 (A), MX47.2 (ROW)
unnamed: D47.2 (A), MX48.2 (ROW)
unnamed: D48.2 (A), MX49.2 (ROW)
unnamed: D49.2 (A), MX50.2 (ROW)
unnamed: D50.2 (A), MX51.2 (ROW)
unnamed: D51.2 (A), MX52.2 (ROW)
unnamed: D52.2 (A), MX53.2 (ROW)
unnamed: D53.2 (A), MX54.2 (ROW)
unnamed: D54.2 (A), MX55.2 (ROW)
unnamed: D56.2 (A), MX58.2 (ROW)
unnamed: D57.2 (A), MX59.2 (ROW)
unnamed: D58.2 (A), MX60.2 (ROW)
unnamed: D59.2 (A), MX61.2 (ROW)
unnamed: D60.2 (A), MX62.2 (ROW)
unnamed: D61.2 (A), MX63.2 (ROW)
unnamed: D62.2 (A), MX64.2 (ROW)
unnamed 115: MX29.3 (LED); also elsewhere on the board
R0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K); also elsewhere on the board
R1: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K); also elsewhere on the board
R2: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K); also elsewhere on the board
R3: D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K); also elsewhere on the board
R4: D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K); also elsewhere on the board

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
Board: 2 copper layers, 285.0 x 95.1 mm, 148 parts (83 on the bottom side), 96 nets.

Other parts of the board:
MX29#2: MX-1.25U; ALPS_PLATE_SPRING_1.25U

Their connections:
C0: MX29#2.1; also elsewhere on the board
unnamed 50: MX29#2.2; also elsewhere on the board
unnamed 115: MX29#2.3; also elsewhere on the board

## Commit log

2018-11-24 schema
2019-03-27 Finished routing, SS
2019-06-30 PCB design
